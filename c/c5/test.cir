V 0 9999 1
R0 0 1 1
R1 100 101 1
R2 200 201 1
R3 300 301 1
R4 400 401 1
R5 500 501 1
R6 600 601 1
R7 700 701 1
R8 800 801 1
R9 900 901 1
R10 1000 1001 1
R11 1100 1101 1
R12 1200 1201 1
R13 1300 1301 1
R14 1400 1401 1
R15 1500 1501 1
R16 1600 1601 1
R17 1700 1701 1
R18 1800 1801 1
R19 1900 1901 1
R20 2000 2001 1
R21 2100 2101 1
R22 2200 2201 1
R23 2300 2301 1
