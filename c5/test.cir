V1 0 1 5
R1 0 2 1000
R2 0 2 2000
R3 0 2 10000
R4 0 3 2000
R5 3 2 500
R6 2 1 250
R7 0 0 10000
